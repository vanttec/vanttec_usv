Commit message: added urdf boat to simulation

File: usv_control/urdf/boat.urdf (robot description, URDF)
Before this commit: robot boat, 1 links, 0 joints
Links:
- link boat: geometry visual mesh filename=package://usv_control/meshes/AssemblyForGazebo.STL scale=0.001 0.001 0.001
